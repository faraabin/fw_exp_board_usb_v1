# IAR project fw_exp_board_usb_v1.ewp, settings and files
configuration fw_exp_board_usb_v1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; ARM_MATH_CM3
  ICCARM.CCIncludePath2: ../src/Core/Inc; ../src/USB_DEVICE/App; ../src/USB_DEVICE/Target; ../src/Drivers/STM32F1xx_HAL_Driver/Inc; ../src/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../src/Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../src/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../src/Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../src/Drivers/CMSIS/Include; ../src/chrono; ../src/faraabin; ../src/Drivers\CMSIS\DSP\Include; ../src/Drivers\CMSIS\Include; C:\Users\ASUS\Desktop\fw_exp_board_usb_v1\src\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fw_exp_board_usb_v1.hex
  ILINK.IlinkOutputFile: fw_exp_board_usb_v1.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../src/Core/Src/: app_signal_generator.c led_function.c main.c stm32f1xx_it.c
    ../src/Drivers/CMSIS/Lib/IAR/: iar_cortexM3l_math.a
  group Application/User/USB_DEVICE/App
    ../src/USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../src/USB_DEVICE/Target/: usbd_conf.c
  group bsp
    ../src/bsp/: bsp.c
  group chrono
    ../src/chrono/: chrono.c
  group Drivers/CMSIS
    ../src/Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../src/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_usb.c
  group faraabin
    ../src/faraabin/: faraabin.c faraabin_database.c faraabin_default_fobjects.c faraabin_fobject_container.c faraabin_fobject_databus.c faraabin_fobject_eventgroup.c faraabin_fobject_function.c faraabin_fobject_mcu.c faraabin_fobject_vartype.c faraabin_function_engine.c faraabin_link_buffer.c faraabin_link_deserializer.c faraabin_link_handler.c faraabin_link_serializer.c
  group faraabin_port
    ../src/Core/Src/: faraabin_port.c
  group Middlewares/USB_Device_Library
    ../src/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../src/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
