<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\fw_exp_board_usb_v1.ewp</path>
  </project>
  <batchBuild />
</workspace>
