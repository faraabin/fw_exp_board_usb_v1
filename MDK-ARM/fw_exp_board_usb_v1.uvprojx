# Keil uVision project fw_exp_board_usb_v1.uvprojx, settings and files
target fw_exp_board_usb_v1 (5060960::V5.06 update 7 for Certification (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: fw_exp_board_usb_v1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,ARM_MATH_CM3
  c include: ..\src\Core\Inc;..\src\library\USB_DEVICE\App;..\src\library\USB_DEVICE\Target;..\src\Drivers\STM32F1xx_HAL_Driver\Inc;..\src\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\src\library\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\src\library\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\src\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\src\Drivers\CMSIS\Include;..\src\library\chrono;..\src\library\faraabin;..\src\Drivers\CMSIS\DSP\Include;..\src\bsp;..\src\app;..\src\faraabin_port
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ../: README.md
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group app
    ../src/app/: app_signal_generator.c led_function.c
  group Application/User/Core
    ../src/Core/Src/: main.c stm32f1xx_it.c
    ../src/Drivers/CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
  group Application/User/USB_DEVICE/App
    ../src/library/USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../src/library/USB_DEVICE/Target/: usbd_conf.c
  group bsp
    ../src/bsp/: bsp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../src/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_usb.c
  group Drivers/CMSIS
    ../src/Core/Src/: system_stm32f1xx.c
  group Middlewares/USB_Device_Library
    ../src/library/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../src/library/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group chrono
    ../src/library/chrono/: chrono.c
  group faraabin
    ../src/library/faraabin/: faraabin.c faraabin_database.c faraabin_default_fobjects.c faraabin_fobject_container.c faraabin_fobject_databus.c faraabin_fobject_eventgroup.c faraabin_fobject_function.c faraabin_fobject_mcu.c faraabin_fobject_vartype.c faraabin_function_engine.c faraabin_link_buffer.c faraabin_link_deserializer.c faraabin_link_handler.c faraabin_link_serializer.c
  group faraabin_port
    ../src/faraabin_port/: faraabin_port.c
software components: CMSIS:CORE 4.3.0
